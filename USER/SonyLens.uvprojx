# Keil uVision project SonyLens.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SonyLens +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\IIC;..\HARDWARE\AT24CXX;..\HARDWARE\SONYLENS;..\HARDWARE\INC;..\HARDWARE\visca;..\HARDWARE\key;..\HARDWARE\lt8618sx;..\HARDWARE\mpr121;..\HARDWARE\EXTI;..\HARDWARE\visca_p;..\HARDWARE\pelco_d;..\HARDWARE\UART;..\HARDWARE\string;..\HARDWARE\STMFLASH;..\HARDWARE\sec
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: startup_stm32f10x_md.s core_cm3.c main.c stm32f10x_it.c system_stm32f10x.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../system/delay/: delay.c
    ../system/sys/: sys.c
    ../system/usart/: usart.c
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/AT24CXX/: at24cxx.c
    ../HARDWARE/SONYLENS/: sony_ui.c sonylens.c cam_test.c
    ../HARDWARE/visca/: visca.c
    ../HARDWARE/visca_p/: visca_p.c
    ../HARDWARE/pelco_d/: pelco_d.c
    ../HARDWARE/UART/: uart2.c uart3.c
    ../HARDWARE/string/: my_string.c
    ../HARDWARE/key/: key.c
    ../HARDWARE/lt8618sx/: lt8618sx.c
    ../HARDWARE/mpr121/: mpr121.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/sec/: sec.c
